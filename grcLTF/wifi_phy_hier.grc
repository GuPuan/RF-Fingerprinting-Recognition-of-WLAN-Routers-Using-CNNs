options:
  parameters:
    category: '[IEEE802.11]'
    generate_options: hb
    id: wifi_phy_hier
    output_language: python
    title: WiFi PHY Hier
  states: {}

blocks:
- name: DC_offset
  id: variable
  parameters:
    value: '-32'
  states: {}
- name: DC_offset_string
  id: variable
  parameters:
    value: str(float(DC_offset))
  states: {}
- name: fre_offset
  id: variable
  parameters:
    value: '4'
  states: {}
- name: fre_offset_string
  id: variable
  parameters:
    value: str(float(fre_offset))
  states: {}
- name: header_formatter
  id: variable
  parameters:
    value: ieee802_11.signal_field()
  states: {}
- name: max_symbols
  id: variable
  parameters:
    value: int(5 + 1 + ((16 + 800 * 8 + 6) * 2) / 24)
  states: {}
- name: phase_noise
  id: variable
  parameters:
    value: '0.311'
  states: {}
- name: phase_noise_string
  id: variable
  parameters:
    value: str(float(phase_noise))
  states: {}
- name: sync_length
  id: variable
  parameters:
    value: '320'
  states: {}
- name: window_size
  id: variable
  parameters:
    value: '48'
  states: {}
- name: bandwidth
  id: parameter
  parameters:
    type: eng_float
    value: 20e6
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: sync_length
    type: complex
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: '16'
    type: complex
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    file: '''/home/buan/桌面/Supporting Material/LeNet/initial_data/ori_data/''+phase_noise_string+''_''+fre_offset_string+''_''+DC_offset_string'
    type: complex
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: window_size
    max_iter: '4000'
    scale: '1'
    type: complex
  states: {}
- name: blocks_moving_average_xx_1
  id: blocks_moving_average_xx
  parameters:
    length: window_size  + 16
    max_iter: '4000'
    scale: '1'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '64'
    type: complex
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: '"packet_len"'
    minoutbuf: max_symbols * 48 * 8
    ninputs: '2'
    tag_preserve_head_pos: '1'
    type: complex
  states: {}
- name: chan_est
  id: parameter
  parameters:
    value: ieee802_11.LS
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    minoutbuf: max_symbols * 48 * 8 * 2
    out_type: complex
    symbol_table: '[-1, 1]'
  states: {}
- name: digital_ofdm_carrier_allocator_cvc_0_0_0
  id: digital_ofdm_carrier_allocator_cvc
  parameters:
    fft_len: '64'
    len_tag_key: '"packet_len"'
    minoutbuf: max_symbols * 48 * 8
    occupied_carriers: (list(range(-26, -21)) + list(range(-20, -7)) + list(range(-6, 0)) + list(range(1, 7)) + list(range(8, 21)) +list( range(22, 27)),)
    output_is_shifted: 'True'
    pilot_carriers: ((-21, -7, 7, 21), )
    pilot_symbols: ((1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1))
    sync_words: ((0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0), (0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0), (0, 0j, 0, 0j, 0, 0j, -1, 1j, -1, 1j, -1, 1j, -1, -1j, 1, 1j, 1, -1j, -1, 1j, 1, 1j, 1, 1j, 1, 1j, -1, (-0-1j), 1, -1j, -1, 1j, 0, -1j, 1, (-0-1j), 1, -1j, 1, 1j, -1, -1j, 1, (-0-1j), -1, 1j, 1, 1j, 1, 1j, 1, 1j, -1, -1j, 1, 1j, 1, -1j, -1, 0j, 0, 0j, 0, 0j), (0, 0, 0, 0, 0, 0, 1, 1, -1, -1, 1, 1, -1, 1, -1, 1, 1, 1, 1, 1, 1, -1, -1, 1, 1, -1, 1, -1, 1, 1, 1, 1, 0, 1, -1, -1, 1, 1, -1, 1, -1, 1, -1, -1, -1, -1, -1, 1, 1, -1, -1, 1, -1, 1, -1, 1, 1, 1, 1, 0, 0, 0, 0, 0))
  states: {}
- name: digital_ofdm_cyclic_prefixer_0_0
  id: digital_ofdm_cyclic_prefixer
  parameters:
    cp_len: '16'
    input_size: '64'
    minoutbuf: max_symbols * 48 * 8 * 10
    rolloff: '2'
    tagname: '"packet_len"'
  states: {}
- name: digital_packet_headergenerator_bb_0
  id: digital_packet_headergenerator_bb
  parameters:
    header_formatter: header_formatter.formatter()
    len_tag_key: '"packet_len"'
  states: {}
- name: encoding
  id: parameter
  parameters:
    value: ieee802_11.BPSK_1_2
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n        \nimport numpy as np\nfrom gnuradio import gr\n\nclass PhaseNoiseBlock(gr.sync_block):\n    \"\"\"Embedded Python Block example - a simple phase noise adder\"\"\"\n\n    def __init__(self, rms_degrees=0.3):\n        \"\"\"Arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='Phase Noise Block',  # Will show up in GRC\n            in_sig=[(np.complex64, 64)],  # Input is a complex vector of length 64\n            out_sig=[(np.complex64, 64)]  # Output is also a complex vector of length 64\n        )\n        # Set the RMS value for phase noise in degrees\n        self.rms_degrees = rms_degrees\n        self.rms_radians = np.deg2rad(self.rms_degrees)  # Convert the RMS value to radians\n\n    def work(self, input_items, output_items):\n        \"\"\"Add phase noise to the input signal\"\"\"\n        # Get the input OFDM signal\n        ofdm_signal = input_items[0]\n        # Generate phase noise with each vector of length 64\n        phase_noise = np.random.normal(0, self.rms_radians, ofdm_signal.shape)\n        # Apply the phase noise to each element\n        output_items[0][:] = ofdm_signal * np.exp(1j * phase_noise)\n        return len(output_items[0])  # Return the length of the output\n\n"
    rms_degrees: phase_noise
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: "\nimport numpy as np\nfrom gnuradio import gr\n\nclass FrequencyOffsetBlock(gr.sync_block):\n    \"\"\"Embedded Python Block example - a simple frequency offset adder\"\"\"\n\n    def __init__(self, freq_offset_ppm=4, sample_rate=20e6, center_freq=5.765e9):\n        \"\"\"Arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='Frequency Offset Block',  # Will show up in GRC\n            in_sig=[(np.complex64, 64)],  # Input is a complex vector of length 64\n            out_sig=[(np.complex64, 64)]  # Output is also a complex vector of length 64\n        )\n        # Set the frequency offset parameters\n        self.freq_offset_ppm = freq_offset_ppm\n        self.sample_rate = sample_rate\n        self.center_freq = center_freq\n        self.freq_offset = self.freq_offset_ppm * 1e-6 * self.center_freq  # Calculate the frequency offset\n\n    def work(self, input_items, output_items):\n        \"\"\"Add frequency offset to the input signal\"\"\"\n        # Get the input OFDM signal\n        ofdm_signal = input_items[0]\n        num_samples = ofdm_signal.shape[1]\n        # Generate the time vector\n        t = np.arange(num_samples) / self.sample_rate\n        # Generate the complex exponential for the frequency offset\n        freq_offset_exp = np.exp(2j * np.pi * self.freq_offset * t)\n        # Apply the frequency offset to each element\n        output_items[0][:] = ofdm_signal * freq_offset_exp\n        return len(output_items[0])  # Return the length of the output\n\n"
    center_freq: frequency
    freq_offset_ppm: fre_offset
    sample_rate: '20000000'
  states: {}
- name: epy_block_0_0_0
  id: epy_block
  parameters:
    _source_code: "\nimport numpy as np\nfrom gnuradio import gr\n\nclass DCOffsetBlock(gr.sync_block):\n    \"\"\"Embedded Python Block example - a simple DC offset adder\"\"\"\n\n    def __init__(self, dc_offset_dBc=-32):\n        \"\"\"Arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='DC Offset Block',  # Will show up in GRC\n            in_sig=[np.complex64],  # Input is a complex data stream\n            out_sig=[np.complex64]  # Output is also a complex data stream\n        )\n        # Set the DC offset value in dBc\n        self.dc_offset_dBc = dc_offset_dBc\n        self.dc_offset = 10 ** (self.dc_offset_dBc / 20.0)  # Convert dBc to a linear scale factor\n\n    def work(self, input_items, output_items):\n        \"\"\"Add DC offset to the input signal\"\"\"\n        # Get the input OFDM signal\n        ofdm_signal = input_items[0]\n        # Apply the DC offset to each element\n        output_items[0][:] = ofdm_signal + self.dc_offset\n        return len(output_items[0])  # Return the length of the output\n\n"
    dc_offset_dBc: DC_offset
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: '64'
    forward: 'False'
    minoutbuf: max_symbols * 48 * 8 * 10
    shift: 'True'
    type: complex
    window: tuple([1/52**.5] * 64)
  states: {}
- name: fft_vxx_0_1
  id: fft_vxx
  parameters:
    fft_size: '64'
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.rectangular(64)
  states: {}
- name: frequency
  id: parameter
  parameters:
    type: eng_float
    value: 5.765e9
  states: {}
- name: ieee802_11_chunks_to_symbols_xx_0
  id: ieee802_11_chunks_to_symbols_xx
  parameters:
    minoutbuf: max_symbols * 48 * 8
  states: {}
- name: ieee802_11_decode_mac_0
  id: ieee802_11_decode_mac
  parameters:
    debug: 'False'
    log: 'False'
  states: {}
- name: ieee802_11_frame_equalizer_0
  id: ieee802_11_frame_equalizer
  parameters:
    algo: chan_est
    bw: bandwidth
    debug: 'False'
    freq: frequency
    log: 'False'
  states: {}
- name: ieee802_11_mapper_0
  id: ieee802_11_mapper
  parameters:
    debug: 'False'
    encoding: encoding
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: samp_out
    type: complex
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: carrier
    optional: 'True'
    type: message
  states: {}
- name: pad_sink_2
  id: pad_sink
  parameters:
    label: mac_out
    optional: 'True'
    type: message
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: samp_in
    type: complex
  states: {}
- name: pad_source_1
  id: pad_source
  parameters:
    label: mac_in
    optional: 'True'
    type: message
  states: {}
- name: sensitivity
  id: parameter
  parameters:
    type: eng_float
    value: '0.56'
  states: {}
- name: sync_long
  id: ieee802_11_sync_long
  parameters:
    debug: 'False'
    log: 'False'
    sync_length: sync_length
  states: {}
- name: sync_short
  id: ieee802_11_sync_short
  parameters:
    debug: 'False'
    log: 'False'
    min_plateau: '2'
    threshold: sensitivity
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', blocks_divide_xx_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_1, '0']
- [blocks_conjugate_cc_0, '0', blocks_multiply_xx_0, '0']
- [blocks_delay_0, '0', sync_long, '1']
- [blocks_delay_0_0, '0', blocks_conjugate_cc_0, '0']
- [blocks_delay_0_0, '0', sync_short, '0']
- [blocks_divide_xx_0, '0', sync_short, '2']
- [blocks_moving_average_xx_0, '0', blocks_complex_to_mag_0, '0']
- [blocks_moving_average_xx_0, '0', sync_short, '1']
- [blocks_moving_average_xx_1, '0', blocks_divide_xx_0, '1']
- [blocks_multiply_xx_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0_1, '0']
- [blocks_tagged_stream_mux_0, '0', digital_ofdm_carrier_allocator_cvc_0_0_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', blocks_tagged_stream_mux_0, '0']
- [digital_ofdm_carrier_allocator_cvc_0_0_0, '0', epy_block_0, '0']
- [digital_ofdm_cyclic_prefixer_0_0, '0', epy_block_0_0_0, '0']
- [digital_packet_headergenerator_bb_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [epy_block_0, '0', fft_vxx_0_0, '0']
- [epy_block_0_0, '0', digital_ofdm_cyclic_prefixer_0_0, '0']
- [epy_block_0_0_0, '0', pad_sink_0, '0']
- [fft_vxx_0_0, '0', epy_block_0_0, '0']
- [fft_vxx_0_1, '0', ieee802_11_frame_equalizer_0, '0']
- [ieee802_11_chunks_to_symbols_xx_0, '0', blocks_tagged_stream_mux_0, '1']
- [ieee802_11_decode_mac_0, out, pad_sink_2, in]
- [ieee802_11_frame_equalizer_0, '0', ieee802_11_decode_mac_0, '0']
- [ieee802_11_frame_equalizer_0, symbols, pad_sink_1, in]
- [ieee802_11_mapper_0, '0', digital_packet_headergenerator_bb_0, '0']
- [ieee802_11_mapper_0, '0', ieee802_11_chunks_to_symbols_xx_0, '0']
- [pad_source_0, '0', blocks_complex_to_mag_squared_0, '0']
- [pad_source_0, '0', blocks_delay_0_0, '0']
- [pad_source_0, '0', blocks_multiply_xx_0, '1']
- [pad_source_1, out, ieee802_11_mapper_0, in]
- [sync_long, '0', blocks_file_sink_0_0_0, '0']
- [sync_long, '0', blocks_stream_to_vector_0, '0']
- [sync_short, '0', blocks_delay_0, '0']
- [sync_short, '0', sync_long, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
